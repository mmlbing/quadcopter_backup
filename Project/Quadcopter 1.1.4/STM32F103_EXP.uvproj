# Keil uVision project STM32F103_EXP.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F102CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32F103_EXP
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\Libraries\CMSIS\CM3\CoreSupport;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\User;.\Libraries;.\Libraries\CMSIS;.\User\MPU6050;.\User\Quadcopter
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Startup
    ./Libraries/CMSIS/CM3/Startup/: startup_stm32f10x_md.s
  group CMSIS
    ./Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./Libraries/CMSIS/: system_stm32f10x.c
  group Libraries
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_exti.c
    ./Libraries/: stm32f10x_it.c
  group User
    ./User/: main.c delay.c led.c quad_uart.c STM32_I2C.c system_init.c
  group Quadcopter
    ./User/Quadcopter/: Motor.c MPU6050.c nRF24L01.c pid.c quadcopter.c pida.c
  group MPU6050
    ./User/MPU6050/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group Readme
    ./User/: readme
