# Keil uVision project STM32F103_EXP.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32F103_EXP
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\Libraries\CMSIS\CM3\CoreSupport;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\User;.\Libraries;.\Libraries\CMSIS
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ./Libraries/CMSIS/CM3/Startup/: startup_stm32f10x_md.s
  group CMSIS
    ./Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./Libraries/CMSIS/: system_stm32f10x.c
  group Libraries
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_adc.c
    ./Libraries/: stm32f10x_it.c
  group User
    ./User/: main.c nRF24L01.c system_init.c handleAD.c handle.c keys.c
